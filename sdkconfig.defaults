## sdkconfig.defaults
```kconfig
# CapLink sdkconfig defaults
# Console goes through USB Serial/JTAG — leaves UART0 free for CapLink JSON-RPC
CONFIG_ESP_CONSOLE_NONE=y
```
